# IAR project FlashPicoCred.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151CB-A ST STM32L151CB-A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CFG_picotag_board; CFG_ENABLE_PICOMAC; CFG_ENABLE_LORAMAC; USE_BAND_868; CFG_sx1276_radio; STM32L1XX_MD; VECT_TAB_OFFSET=0x2800; SECTION_PRIVATE_START=0x20; SECTION_PRIVATE_LENGTH=0xBE0; SECTION_COMMON_START=0xC20; SECTION_COMMON_LENGTH=0x3E0
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\common\mac; ..\..\..\..\common\mac\pico-mac; ..\..\..\..\common\mac\lora-mac; ..\..\..\..\common\os; ..\..\..\..\common\utils; ..\..\..\..\common\radio; ..\..\..\..\common\sensors; ..\..\..\..\common\stm32\STM32L1; ..\..\..\..\common\stm32\includes; ..\..\..\..\..\libs\STM32L1xx_StdPeriph_Lib_V1.3.0\Libraries\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashPicoCred.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\common\stm32\STM32L1\iar\stm32l15xx6-picotag.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\common\mac\lib\iar\STM32L1\libpicomac.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group includes
    ../../../../common/stm32/includes/: accelerometer.h button.h flash.h gpio.h i2c.h led.h spi.h system.h tick.h usart.h
  group Mac
    ../../../../common/mac/: cmac.c cmac.h common.h mac.c mac.h mac_interface.h message.c message.h message_common.h message_interface.h mic.c mic.h osal.c osal.h
  group Mac/LoraMac
    ../../../../common/mac/lora-mac/: lora_mac.c lora_mac.h lora_mac_internal.h message_lora.c message_lora.h
  group Mac/PicoMac
    ../../../../common/mac/pico-mac/: message_picowan.h pico_mac.h pico_mac_internal.h
  group OS
    ../../../../common/os/: os.c os.h
  group Project
    ../../: main.c
  group Radio
    ../../../../common/radio/: radio.c radio.h
  group Sensors
    ../../../../common/sensors/: lis2de12.c lis2de12.h
  group STM32L1
    ../../../../common/stm32/STM32L1/: accelerometer.c arch.h boards.h button.c clocks.c clocks.h flash.c gpio.c i2c-internal.c i2c-internal.h i2c.c led.c spi.c stm32l1xx.h system.c system_stm32l1xx.c system_stm32l1xx.h tick.c usart.c
    ../../../../common/stm32/STM32L1/iar/: startup_stm32l1xx_md_iar.s
  group Utils
    ../../../../common/utils/: aes.c aes.h console.c console.h crc8.c crc8.h lora_certif.c lora_certif.h utils.c utils.h xprintf.c xprintf.h
