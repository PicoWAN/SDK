# IAR project FlashKeys.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L072CZ ST STM32L072CZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CFG_murata_discovery_board; CFG_ENABLE_PICOMAC; CFG_ENABLE_LORAMAC; USE_BAND_868; CFG_sx1276_radio; STM32L072xx; ARM_MATH_CM0PLUS; SECTION_PRIVATE_START=0x0; SECTION_PRIVATE_LENGTH=0xC00; SECTION_COMMON_START=0xC00; SECTION_COMMON_LENGTH=0xC00
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\common\mac; ..\..\..\..\common\mac\pico-mac; ..\..\..\..\common\mac\lora-mac; ..\..\..\..\common\os; ..\..\..\..\common\utils; ..\..\..\..\common\radio; ..\..\..\..\common\sensors; ..\..\..\..\common\stm32\STM32L0; ..\..\..\..\common\stm32\includes; ..\..\..\..\..\libs\STM32Cube_FW_L0_V1.9.0\Drivers\CMSIS\Include; ..\..\..\..\..\libs\STM32Cube_FW_L0_V1.9.0\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\libs\STM32Cube_FW_L0_V1.9.0\Drivers\STM32L0xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashKeys.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\common\stm32\STM32L0\iar\stm32l0xxxz.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\common\mac\lib\iar\STM32L0\libpicomac.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group includes
    ../../../../common/stm32/includes/: accelerometer.h button.h flash.h gpio.h i2c.h led.h spi.h system.h tick.h usart.h
  group Mac
    ../../../../common/mac/: cmac.c cmac.h common.h mac.c mac.h mac_interface.h message.c message.h message_common.h message_interface.h mic.c mic.h osal.c osal.h
  group Mac/LoraMac
    ../../../../common/mac/lora-mac/: lora_mac.c lora_mac.h lora_mac_internal.h message_lora.c message_lora.h
  group Mac/PicoMac
    ../../../../common/mac/pico-mac/: message_picowan.h pico_mac.h pico_mac_internal.h
  group OS
    ../../../../common/os/: os.c os.h
  group Project
    ../../: main.c
  group Radio
    ../../../../common/radio/: radio.c radio.h
  group Sensors
    ../../../../common/sensors/: lis2de12.c lis2de12.h
  group STM32L0
    ../../../../common/stm32/STM32L0/: accelerometer.c arch.h boards.h button.c flash.c gpio.c i2c.c led.c spi.c stm32l0xx_hal_conf.h stm32l0xx_it.c stm32l0xx_it.h system.c system_stm32l0xx.c tick.c usart.c
    ../../../../common/stm32/STM32L0/iar/: startup_stm32l0x2xx_iar.s
  group STMCubeL0
    ../../../../../libs/STM32Cube_FW_L0_V1.9.0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
  group Utils
    ../../../../common/utils/: aes.c aes.h console.c console.h crc8.c crc8.h lora_certif.c lora_certif.h utils.c utils.h xprintf.c xprintf.h
